	AREA BOOTHALGO,CODE
		ENTRY
	EXPORT __START
__START
	MOV R0,#3	; MULTIPLIER OR B
	MOV R1,#7	; MULTIPLICAND
	MOV R2,#0	; A
	MOV R3,#0	; Q_-1
	MOV R4,R0	; Q AND (AT LAST WILL GIVE FINAL ANSWER)
	MOV R5,#32	; N
	MOV R6,#0	; COUNT
	LOOP:
		CMP R6,R5
		BEQ ENDL
		AND R7,R4,#1
		ADD R7,R3,R7,LSL #1	;Q_0Q_-1
		CMP R7,#1
		BEQ ADDB
		CMP R7,#2
		BEQ SUBB
		BNE RSHIFT
	RSHIFT:
		AND R7,R4,#1
		MOV R3,R7	; Q_-1 SHIFTED
		MOV R4,R4,LSR #1
		AND R7,R2,#1
		CMP R7,#1
		ADDEQ R4,R4,#0X80000000	; Q SHIFTED
		MOV R2,R2,ASR #1	; A SHIFTED
		ADD R6,R6,#1
		B LOOP
	ADDB:
		ADD R2,R2,R0	;A+B
		B RSHIFT
	SUBB:
		SUB R2,R2,R0	;A-B
		B RSHIFT
	ENDL:
		END